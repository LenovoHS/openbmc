#"Copyright (c) 2019-present Lenovo
#Licensed under BSD-3, see COPYING.BSD file for details."

OBMC_IMAGE_EXTRA_INSTALL_append_hr630 = " phosphor-ipmi-blobs phosphor-ipmi-flash lenovo-ipmi-oem rest-dbus lenovo-bmc-update lenovo-bios-update"
